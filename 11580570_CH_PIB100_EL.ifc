Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: b000954b-dd19-42ec-924b-da212f2c26cb, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-15T10:44:10+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11580570_CH_PIB100_EL:53100011_CH_11580570_PIB100_EL, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Connection_Dampf, z_Miele_Design_BRWS, z_Miele_Design_Cast, z_Miele_Design_CLST, SAN Plastic, z_Miele_Connection_Electric, <Unnamed>
Type - Pset_ProductRequirements - Category: Specialty Equipment
Classification: E1010620 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 53100011_CH_11580570_PIB100_EL; sets with these values: 2

# IfcDistributionPort, Port_355176_1
Description: Flow; FlowDirection: SOURCEANDSINK
